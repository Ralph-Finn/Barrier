# Keil uVision project CH554_ADB.uvproj, settings and files
target Target 1 (MCS-51)
  device: SST89C54 SST
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) CLOCK(33000000)
  output: CH554DEMO +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./Public/: Debug.C
    ./USB/Host/: USBHostHUB_KM.C
    ./USB/USB_LIB/: USBHOST.C
